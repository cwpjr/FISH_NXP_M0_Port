# IAR project FISH_M0.ewp, settings and files
configuration NXP_81x_PubRel (ARM, debug)
  General.OGChipSelectEditMenu: LPC812M101 NXP LPC812M101
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: NXP_M0_812; FISH_PubRel_WORDSET; NXP_M0_81x_IRC12_24MHZ; NXP_M0_016kFlash_1KWrite; NXP_M0_004kRam
  AARM.AUserIncludes: ..\FISH_RM_COMMON; ..\FISH_RM_COMMON_CODE_CORTEX_M
  OBJCOPY.OOCOutputFile: FISH_FORTH_NXP_M0_812_PUBREL_RM_v1.7.hex
  ILINK.IlinkOutputFile: FISH_FORTH_NXP_M0_812_PUBREL_RM_v1.7.out
  ILINK.IlinkIcfFile: FISH_M0.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration NXP_81x_PubRel_SRM (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: SRM; NXP_M0_812; FISH_PubRel_WORDSET; NXP_M0_81x_IRC12_24MHZ; NXP_M0_016kFlash_1KWrite; NXP_M0_004kRam
  OBJCOPY.OOCOutputFile: FISH_FORTH_NXP_M0_812_PUBREL_SRM_v1.7.hex
  ILINK.IlinkOutputFile: FISH_FORTH_NXP_M0_812_PUBREL_SRM_v1.7.out
configuration NXP_81x_PubRel_mBed_MAX (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: NXP_M0_812; NXP_812_mBed_MAX; FISH_PubRel_WORDSET; NXP_M0_81x_IRC12_24MHZ; NXP_M0_016kFlash_1KWrite; NXP_M0_004kRam
  OBJCOPY.OOCOutputFile: FISH_FORTH_NXP_M0_812_PUBREL_RM_mBED_MAX_v1.7.hex
  ILINK.IlinkOutputFile: FISH_FORTH_NXP_M0_812_PUBREL_RM_mBED_MAX_v1.7.out
configuration NXP_11xx_32X8_PUBREL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1114FDH28_102 NXP LPC1114FDH28_102
  AARM.ADefines: NXP_M0_11xx; FISH_PubRel_WORDSET; NXP_M0_11xx_IRC12_48MHZ; NXP_M0_032kFlash_4KWrite; NXP_M0_008kRam
  OBJCOPY.OOCOutputFile: FISH_FORTH_NXP_M0_11xx_32X8_PUBREL_RM_v1.7.hex
  ILINK.IlinkOutputFile: FISH_FORTH_NXP_M0_11xx_32X8_PUBREL_RM_v1.7.out
configuration NXP_11xx_32X4_PUBREL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1114FDH28_102 NXP LPC1114FDH28_102
  AARM.ADefines: NXP_M0_11xx; FISH_PubRel_WORDSET; NXP_M0_11xx_IRC12_48MHZ; NXP_M0_032kFlash_4KWrite; NXP_M0_004kRam
  OBJCOPY.OOCOutputFile: FISH_FORTH_NXP_M0_11xx_32X4_PUBREL_RM_v1.7.hex
  ILINK.IlinkOutputFile: FISH_FORTH_NXP_M0_11xx_32X4_PUBREL_RM_v1.7.out
configuration NXP_81x_PUBREL_SRM_mBED_MAX (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: SRM; NXP_M0_812; NXP_812_mBed_MAX; FISH_PubRel_WORDSET; NXP_M0_81x_IRC12_24MHZ; NXP_M0_016kFlash_1KWrite; NXP_M0_004kRam
  OBJCOPY.OOCOutputFile: FISH_FORTH_NXP_M0_812_PUBREL_SRM_mBED_MAX_v1.7.hex
  ILINK.IlinkOutputFile: FISH_FORTH_NXP_M0_812_PUBREL_SRM_mBED_MAX_v1.7.out
configuration NXP_11xx_32X8_PRO (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1114FDH28_102 NXP LPC1114FDH28_102
  AARM.ADefines: NXP_M0_11xx; FISH_NXP_M0_PRO_WORDCAT; NXP_M0_11xx_IRC12_48MHZ; NXP_M0_032kFlash_4KWrite; NXP_M0_008kRam
  OBJCOPY.OOCOutputFile: FISH_FORTH_NXP_M0_11xx_32X8_PRO_RM_v1.7.hex
  ILINK.IlinkOutputFile: FISH_FORTH_NXP_M0_11xx_32X8_PRO_RM_v1.7.out
configuration NXP_11xx_32X4_PRO (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1114FDH28_102 NXP LPC1114FDH28_102
  AARM.ADefines: NXP_M0_11xx; FISH_NXP_M0_PRO_WORDCAT; NXP_M0_11xx_IRC12_48MHZ; NXP_M0_032kFlash_4KWrite; NXP_M0_004kRam
  OBJCOPY.OOCOutputFile: FISH_FORTH_NXP_M0_11xx_32X4_PRO_RM_v1.7.hex
  ILINK.IlinkOutputFile: FISH_FORTH_NXP_M0_11xx_32X4_PRO_RM_v1.7.out
configuration NXP_1115_64X8_PUBREL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1115FBD48_303 NXP LPC1115FBD48_303
  AARM.ADefines: NXP_M0_1115; FISH_PubRel_WORDSET; NXP_M0_11xx_IRC12_48MHZ; NXP_M0_064kFlash_4KWrite; NXP_M0_008kRam
  OBJCOPY.OOCOutputFile: FISH_FORTH_NXP_M0_1115_64X8_PUBREL_RM_v1.7.hex
  ILINK.IlinkOutputFile: FISH_FORTH_NXP_M0_1115_64X8_PUBREL_RM_v1.7.out
  group (top)
    ./: cstartup_M.c FISH_M0.icf FISH_NXP_M0_IAR.s FISH_NXP_M0_main.c
